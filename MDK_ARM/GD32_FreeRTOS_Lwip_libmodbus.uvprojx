# Keil uVision project GD32_FreeRTOS_Lwip_libmodbus.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.4.0
  cpu: IRAM(0x24000000,0x000E0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00010000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GD32_FreeRTOS_Lwip_libmodbus +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32H7XX
  c include: ..\App\inc;..\Bsp\inc;..\GD32H7xx_Firmware_Library\GD32H7xx_standard_peripheral\Include;..\GD32H7xx_Firmware_Library\CMSIS\GD\GD32H7xx\Include;..\Middleware\FreeRTOS;..\Middleware\FreeRTOS\inc;..\Middleware\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\Middleware\Lwip;..\Middleware\Lwip\port;..\Middleware\Lwip\port\arch;..\Middleware\Lwip\src\include;..\Middleware\Lwip\src\include\compat;..\Middleware\Lwip\src\include\lwip;..\Middleware\Lwip\src\include\netif;..\Middleware\Lwip\src\include\compat\posix\sys;..\Middleware\Lwip\src\include\compat\posix;..\Middleware\libmodbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  group App
    ../App/src/: gd32h7xx_it.c main.c systick.c app_task.c
  group Bsp
    ../Bsp/src/: bsp.c usart.c enet.c led.c
  group Peripherals
    ../GD32H7xx_Firmware_Library/GD32H7xx_standard_peripheral/Source/: gd32h7xx_adc.c gd32h7xx_can.c gd32h7xx_cau.c gd32h7xx_cau_aes.c gd32h7xx_cau_des.c gd32h7xx_cau_tdes.c gd32h7xx_cmp.c gd32h7xx_cpdm.c gd32h7xx_crc.c gd32h7xx_ctc.c gd32h7xx_dac.c gd32h7xx_dbg.c gd32h7xx_dci.c gd32h7xx_dma.c gd32h7xx_edout.c gd32h7xx_efuse.c gd32h7xx_enet.c gd32h7xx_exmc.c gd32h7xx_exti.c gd32h7xx_fac.c gd32h7xx_fmc.c gd32h7xx_fwdgt.c gd32h7xx_gpio.c gd32h7xx_hau.c gd32h7xx_hau_sha_md5.c gd32h7xx_hpdf.c gd32h7xx_hwsem.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_lpdts.c gd32h7xx_mdio.c gd32h7xx_mdma.c gd32h7xx_misc.c gd32h7xx_ospi.c gd32h7xx_ospim.c gd32h7xx_pmu.c gd32h7xx_rameccmu.c gd32h7xx_rcu.c gd32h7xx_rspdif.c gd32h7xx_rtc.c gd32h7xx_rtdec.c gd32h7xx_sai.c gd32h7xx_sdio.c gd32h7xx_spi.c gd32h7xx_syscfg.c gd32h7xx_timer.c gd32h7xx_tli.c gd32h7xx_tmu.c gd32h7xx_trigsel.c gd32h7xx_trng.c gd32h7xx_usart.c gd32h7xx_vref.c gd32h7xx_wwdgt.c
  group CMSIS
    ../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group Startup
    ../GD32H7xx_Firmware_Library/CMSIS/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
  group Lwip/API
    ../Middleware/Lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Lwip/Core
    ../Middleware/Lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Lwip/Core/IPv4
    ../Middleware/Lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Lwip/Port
    ../Middleware/Lwip/port/arch/: sys_arch.c
    ../Middleware/Lwip/port/: ethernetif.c
  group Lwip/netif
    ../Middleware/Lwip/src/netif/: ethernet.c
  group FreeRTOS
    ../Middleware/FreeRTOS/src/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middleware/FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c
    ../Middleware/FreeRTOS/portable/MemMang/: heap_4.c
  group libmodbus
    ../Middleware/libmodbus/: modbus.c modbus-data.c modbus-tcp.c
software components: CMSIS:CORE 5.5.0
